# Allegro board R818_REF_DDR4_16X2_V1_5.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SDQS0P: length 20.2
  TOP w0.097: UD1.G3 4.7,12.03 5,12.33 5.42,12.33 6.15,13.06 6.15,13.27 6.25,13.37 6.37,13.37 v1(6.37,13.37) ; v1(10.45,25.34) 10.36,25.42 10.36,25.63 10.61,25.87 13.07,25.87 13.15,25.96 U1.Y2
  POWER03 w0.097: v1(6.37,13.37) 6.37,13.42 6.29,13.5 6.29,13.64 6.49,13.84 6.49,15.7 5.74,16.44 5.74,18.92 6.99,20.17 6.99,21.27 10.23,24.51 10.23,25.12 v1(10.45,25.34)
SDQS1N: length 18.4
  TOP w0.076: 12.32,23.28 12.32,23.36 13.29,24.32 U1.AC2
  TOP w0.097: UD1.A7 8.01,16.7 8.1,16.6 8.1,16.36 7.99,16.25 7.76,16.25 7.56,16.05 7.36,16.05 7.27,15.95 7.27,15.75 7.17,15.65 7.17,14.97 7.01,14.82 6.74,14.82 6.64,14.91 6.64,16.01 7.07,16.45 7.07,16.97 6.74,17.31 6.74,17.71 7.14,18.11 8.26,18.11 8.75,18.6 8.75,19.26 8.23,19.79 8.23,20.02 8.49,20.29 8.63,20.29 8.95,19.96 9.41,19.96 10.02,20.57 10.02,20.89 10.23,21.1 10.23,21.25 10.02,21.46 10.02,21.64 11.5,23.12 12.16,23.12 12.32,23.28
SDQS1P: length 18.5
  TOP w0.076: U1.AB2 13.29,24.82 13.04,24.57 13.04,24.32 12.22,23.51 12.1,23.51
  TOP w0.097: UD1.B7 7.86,15.9 7.48,15.52 7.48,14.84 7.14,14.5 6.61,14.5 6.32,14.78 6.32,16.15 6.76,16.58 6.76,16.84 6.42,17.18 6.42,17.84 7.01,18.43 8.13,18.43 8.41,18.71 8.41,19.15 7.91,19.66 7.91,20.15 8.36,20.6 8.76,20.6 9.08,20.28 9.28,20.28 9.71,20.7 9.71,21.77 11.37,23.44 12.03,23.44 12.1,23.51
SDQS2N: length 12.2
  TOP w0.076: 15.91,23.64 15.91,23.86 15.71,24.06 15.71,24.33 15.79,24.4 U1.AC7
  TOP w0.097: 15.91,23.64 15.91,22 14.75,20.83 14.75,19.73 16.93,17.55 16.93,17.06 17.01,16.98 17.01,16.82 16.93,16.74 16.93,16.56 17.22,16.26 17.49,16.26 17.49,16.27 17.59,16.37 17.79,16.37 17.9,16.26 18.14,16.26 18.21,16.33 18.44,16.33 18.51,16.26 18.81,16.26 18.91,16.36 18.91,16.54 18.75,16.7 UD2.A7
SDQS2P: length 12.4
  TOP w0.076: U1.AB7 15.69,24.86 15.69,24.71 15.65,24.67 15.54,24.56 15.54,23.99 15.6,23.93 15.6,23.69
  TOP w0.097: 15.6,23.69 15.6,22.13 14.43,20.96 14.43,19.6 16.61,17.42 16.61,16.42 17.09,15.94 18.65,15.94 UD2.B7
SDQS3N: length 15.4
  TOP w0.076: 17.19,23.89 17.19,23.95 17.1,24.04 17.1,24.17 17.03,24.24 17.03,24.85 17.04,24.85 17.04,25.06 17.29,25.31 U1.AA10
  TOP w0.097: v1(16.83,13.25) 16.46,13.25 16.29,13.08 16.29,12.88 15.9,12.48 15.71,12.48 UD2.F3 ; 17.19,23.89 17.19,21.65 v1(17.34,21.5)
  POWER03 w0.097: v1(17.34,21.5) 17.13,21.5 15.88,20.25 15.88,16.64 16.77,15.75 16.77,13.32 16.83,13.26 v1(16.83,13.25)
SDQS3P: length 15.6
  TOP w0.076: U1.AB10 17.21,24.89 17.21,24.78 17.21,24.78 17.21,24.31 17.28,24.24 17.28,24.11 17.5,23.89
  TOP w0.097: UD2.G3 15.5,11.9 15.5,11.98 15.69,12.17 16.03,12.17 16.52,12.66 v1(16.68,12.66) ; 17.5,23.89 17.5,22.08 v1(17.59,21.99)
  POWER03 w0.097: v1(17.59,21.99) 17.46,21.86 17.04,21.86 15.56,20.38 15.56,16.51 16.45,15.62 16.45,12.81 16.61,12.66 v1(16.68,12.66)
SODT0: length 49.3
  TOP w0.076: 21.65,23.17 21.65,23.24 20.68,24.21 20.54,24.35 20.54,24.59 20.79,24.84 U1.AB17
  TOP w0.102: UD2.K3 15.84,9.5 17.14,10.8 v1(17.14,10.97) 17.41,10.7 17.41,8.27 18.19,7.49 19.67,7.49 19.91,7.25 19.91,6.95 20.21,6.65 20.51,6.65 21.25,5.92 23.67,5.92 26.06,8.31 26.06,15.08 25.73,15.41 25.73,19.58 24.76,20.54 24.02,20.54 22.79,21.77 22.31,21.77 21.67,22.41 21.67,23.15 21.65,23.17 ; v1(5.21,9.5) UD1.K3
  POWER03 w0.102: v1(17.14,10.97) 17.13,10.99 16.24,10.99 16.09,11.14 14.81,11.14 14.57,11.38 9.49,11.38 9.25,11.14 8.73,11.14 8.71,11.16 8.18,11.16 7.26,10.24 5.66,10.24 5.21,9.79 v1(5.21,9.5)
SRAS: length 41.8
  TOP w0.102: UD2.L8 19.9,9.1 20.73,9.1 20.83,9.2 v1(20.83,9.21) 20.91,9.21 21.34,8.79 21.48,8.79 21.89,9.2 21.89,9.34 21.61,9.62 21.61,9.78 21.73,9.9 21.9,9.9 22.07,9.73 22.25,9.73 22.37,9.85 22.37,10.01 21.91,10.47 21.91,10.65 22.03,10.76 22.19,10.76 22.65,10.3 22.82,10.3 22.94,10.42 22.94,10.59 22.63,10.9 22.63,11.05 22.75,11.17 22.93,11.17 23.23,10.88 23.4,10.88 24.64,12.12 24.64,14.49 23.83,15.3 23.83,15.44 23.93,15.54 24.03,15.54 24.14,15.64 24.14,15.85 24.04,15.95 23.76,15.95 23.55,15.73 23.4,15.73 23.03,16.11 23.03,16.25 23.13,16.35 23.99,16.35 24.14,16.5 24.14,16.84 23.94,17.03 23.68,17.03 23.55,17.16 23.37,17.16 23.28,17.25 23.28,17.46 23.42,17.6 23.91,17.6 23.99,17.68 23.99,17.96 23.89,18.06 23.63,18.06 23.5,18.19 23.5,18.33 23.79,18.62 23.79,18.87 22.26,20.4 22.05,20.4 20.75,21.7 20.75,23.23 19.9,24.08 19.9,24.34 U1.AC15 ; v1(10.89,9.45) 10.51,9.08 9.09,9.08 UD1.L8
  POWER03 w0.102: v1(10.89,9.45) 10.89,9.46 15.29,9.46 15.46,9.29 17.89,9.29 18.48,8.7 19.7,8.7 19.85,8.84 20.01,8.84 20.16,8.7 20.32,8.7 20.83,9.21 v1(20.83,9.21)
SRST: length 59.6
  TOP w0.102: v1(21.31,26.97) 21.28,26.97 U1.U17 ; v1(3.5,4.31) 3.5,5.9 UD1.P1 ; UD2.P1 14.3,5.89 14.3,3.62 14.68,3.24 14.68,1.8 14.82,1.66 v1(14.82,1.19)
  POWER03 w0.102: 14.82,1.24 14.74,1.24 14.66,1.16 9.01,1.16 6.87,3.3 5.18,3.3 4.17,4.31 v1(3.5,4.31) ; 14.82,1.24 14.95,1.24 15.02,1.16 15.75,1.16 16.75,2.16 22.49,2.16 22.87,2.54 23.67,2.54 27.43,6.3 27.43,20.11 26,21.54 26,22.14 25.26,22.88 25.26,23.05 23.18,25.12 22.38,25.12 21.93,25.58 21.93,26.51 21.47,26.97 v1(21.31,26.97) ; 14.82,1.24 v1(14.82,1.19)
STEN1: length 5.9
  TOP w0.102: UD1.N9 10.79,7.1 11.1,6.79 11.1,5.86 11,5.76 11,2.94 RD1.1
STEN2: length 3
  TOP w0.102: RD2.1 22.03,7.25 21.69,6.91 20.48,6.91 UD2.N9
SVREF: length 27.8
  TOP w0.356: RD8.1 6.24,0.26 11.43,0.26 12.1,0.92 12.1,2.2 CD34.1 12.24,2.86 12.24,6.8 13.33,7.9 UD2.M1
  TOP w0.4: UD1.M1 1.86,6.65 1.86,6.2 0.92,5.26 CD35.1 0.49,4.7 ; RD8.1 5.05,1.05 5.04,1.06 CD33.1 RD7.2
  TOP w0.406: RD7.2 1.98,1.06 0.49,2.56 0.49,4.7
SWE: length 41.2
  TOP w0.076: U1.AA12 18.04,25.21 18.04,24.85 18.23,24.66 18.23,24.2 18.23,24.2 18.37,24.06 18.37,23.9
  TOP w0.102: 18.37,23.9 18.37,22.73 18.61,22.48 18.61,22.2 18.73,22.08 18.73,21.24 18.44,20.95 18.44,20.43 18.69,20.18 v1(19.07,20.18) ; UD1.L2 v1(4.3,8.3) ; UD2.L2 v1(15.1,9.1)
  POWER03 w0.102: v1(4.3,8.3) 4.3,8.41 4.98,9.08 5.45,9.08 6.25,8.28 7.77,8.28 8.17,8.68 8.6,8.68 8.69,8.77 9.37,8.77 9.69,9.09 12.84,9.09 13.19,8.74 14.38,8.74 14.74,9.1 v1(15.1,9.1) 15.26,8.93 17.74,8.93 18.33,8.34 20.98,8.34 21.33,8.69 21.33,9.64 21.71,10.02 21.71,10.43 21.36,10.78 21.36,11.29 21.98,11.91 21.98,17.11 21.45,17.63 21.26,17.82 21.26,18.45 21.64,18.83 21.64,19.02 21.23,19.43 21.23,20.14 21.04,20.33 19.22,20.33 v1(19.07,20.18)
N16281101: length 2.4
  TOP w0.102: U1.Y19 22.32,25.96 v1(22.34,25.93)
  BOTTOM w0.254: RD5.1 23.45,25.83 22.45,25.83 v1(22.34,25.93)
N17928021: length 11.5
  TOP w0.102: RD3.1 1.84,9.45 v1(1.87,9.48) ; UD1.F9 v1(10.01,12.7)
  POWER03 w0.102: v1(10.01,12.7) 9,12.7 8.66,12.36 8.66,12.15 8.42,11.9 7.88,11.9 6.89,10.92 5.16,10.92 4.18,9.94 2.33,9.94 v1(1.87,9.48)
N17931224: length 2.8
  TOP w0.102: RD4.1 22.85,12.7 UD2.F9

## Copper pours and planes (outline as drawn)
GND on BOTTOM: outline of 81 points within 1.79,11.36 20.14,27.71
GND on GND02: -0.03,36.08 -0.03,0.17 27.52,0.17 27.52,36.08
VCC25-DRAM on TOP: 23.42,4.21 23.87,4.21 24.49,3.59 25.56,3.59 25.72,3.43 25.72,2.89 25.13,2.3 24.55,2.3 23.23,3.61 23.23,4.08 23.36,4.21 23.42,4.21
VCC25-DRAM on POWER03: 25.79,2.51 25.79,3.39 25.66,3.53 25.41,3.53 24.26,2.38 24.26,1.74 25.03,1.74
VCC-DRAM on BOTTOM: -0.13,-0.03 -0.13,17.1 0.38,17.61 1.14,17.61 1.3,17.45 1.3,17.16 2.05,16.42 2.86,16.42 3.35,15.92 4.48,15.92 4.85,15.55 4.85,12.62 4.64,12.41 4.64,11.5 4.92,11.22 6.97,11.22 8.34,12.59 8.58,12.59 8.86,12.87 8.86,13.27 9,13.41 9.28,13.41 9.37,13.31 9.74,13.31 10.45,12.6 13.83,12.6 13.96,12.47 13.96,12.46 14.45,11.97 15.55,11.97 15.87,11.65 17.3,11.65 17.3,11.66 17.63,11.66 18.03,12.06 18.03,12.38 18.28,12.64 19.32,12.64 20.29,13.61 20.29,14.69 19.36,15.62 18.86,15.62 18.61,15.87 18.61,16.34 17.67,17.28 17.67,19.44 18.85,20.61 18.85,20.62 18.93,20.7 18.93,21.82 19.1,21.99 19.1,23.41 19.31,23.63 19.31,23.86 19.31,23.86 19.31,27.03 18.59,27.75 16.33,27.75 16.21,27.87 16.21,28.56 16.48,28.83 17.37,28.83 17.67,28.53 17.67,28.52 17.77,28.43 18.69,28.43 18.7,28.44 20.51,28.44 20.51,28.43 21.18,27.76 21.21,27.76 22.09,26.88 22.09,26.58 27.81,20.86 27.81,-0.03
VCC-DRAM on POWER03: 10.41,19.1 10.94,19.1 11.25,18.79 11.25,14.17 12.05,13.37 12.64,13.37 13.09,13.83 13.09,14.8 12.64,15.26 12.64,16.93 12.96,17.25 13.7,17.25 14.08,16.86 14.08,14.65 14.34,14.38 14.34,12.2 14,11.86 9.79,11.86 9.62,12.03 9.62,12.28 9.76,12.42 10.32,12.42 10.38,12.48 10.38,12.79 10.1,13.08 9.86,13.08 9.61,13.32 9.61,17.28 10.25,17.92 10.25,18.99 10.39,19.13 10.39,19.13
VCC-DRAM on POWER03: 3.89,18.87 4.39,18.87 4.72,18.55 4.72,15.29 4.51,15.09 4.11,15.09 3.88,15.32 3.88,15.63 3.6,15.9 2.31,15.9 2.23,15.98 2.23,16.48 2.89,17.14 2.89,17.99 3.74,18.84 3.85,18.84

Small or netless copper shapes (teardrops, artwork): 4 on TOP
